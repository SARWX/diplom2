# Keil uVision project diplom2.uvprojx, settings and files
target stm_programm (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diplom2
  c flags: Optim=6 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, TX_BROADCAST_PROGRAM
  c include: .\decadriver;.\platform;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\user;.\user\my_lib;.\user\devices\anchor;.\user\devices\main_anchor;.\user\devices\tag;.\user\protocols
  asm define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
  group decadriver
    ./decadriver/: deca_device.c deca_params_init.c
  group platform
    ./platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c stm32f10x_it.c
  group STM32_StdPeriph
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group my_lib
    ./user/my_lib/: net_mac.c net_mac.h device_id.h device_id.c cmd_parser.h cmd_parser.c net_devices.h net_devices.c ss_twr.h ss_twr.c common.h common.c net_dispatch.h net_dispatch.c
  group devices
    ./user/devices/anchor/: anchor.h anchor.c
    ./user/devices/main_anchor/: main_anchor.h main_anchor.c uart.h uart.c
    ./user/devices/tag/: tag.h tag.c
  group protocols
    ./user/protocols/: enumeration.c enumeration.h configuration.c configuration.h meas_table.c meas_table.h ranging.c ranging.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
